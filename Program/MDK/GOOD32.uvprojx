# Keil uVision project GOOD32.uvprojx, settings and files
target good32 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GOOD32 +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: TM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\FWlib\inc;..\uCos-III\uC_CFG;..\uCos-III\uC-CPU;..\uCos-III\uC-CPU\ARM-Cortex-M3\RealView;..\uCos-III\uC-LIB;..\uCos-III\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\uCos-III\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\uCos-III\uCOS-III\Source;..\APP;..\HAL;..\HDL
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../APP/: main.c app.c app_cfg.h includes.h stm32f10x_it.c stm32f10x_it.h
  group HDL
    ../HDL/: hdl_enc28j60.c hdl_enc28j60.h
  group HAL
    ../HAL/: hal_init.c hal_init.h hal_io.c hal_io.h hal_uart.c hal_uart.h hal_spi.c hal_spi.h hal_rtc.c hal_rtc.h hal_iwdg.c hal_iwdg.h hal_wwdg.c hal_wwdg.h hal_tim.c hal_tim.h hal_pwm.c hal_pwm.h hal_adc.c hal_adc.h hal_dac.c hal_dac.h hal_can.c hal_can.h hal_fsmc.c hal_fsmc.h hal_sdio.c hal_sdio.h hal_usb.h hal_usb.c hal_i2c.c hal_i2c.h
  group STLIB
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uC/CFG
    ../uCos-III/uC_CFG/: os_cfg.h cpu_cfg.h lib_cfg.h os_cfg_app.h os_app_hooks.c os_app_hooks.h
  group uC/CPU
    ../uCos-III/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
    ../uCos-III/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../uCos-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../uCos-III/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../uCos-III/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/OS-III Port
    ../uCos-III/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu.h os_cpu_a.s
  group CMSIS
    ../CMSIS/: core_cm3.c core_cm3.h system_stm32f10x.c system_stm32f10x.h stm32f10x.h
  group STARTUP
    ../CMSIS/startup/arm/: startup_stm32f10x_hd.s
